# Keil uVision project 温室大棚.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: 温室大棚 +hex
  c flags: Optimize=9
  group Source Group 1
    ./: STARTUP.A51
  group Core
    ./Core/: main.c lcd12864_s.c delay.c dht11.c usart.c bh1750.c pwm.c rc522.c matkey.c
