# Keil uVision project 电梯控制系统.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: 电梯控制系统 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
  group Core
    ./Core/: main.c
  group Hardware
    ./Core/: delay.c lcd12864_s.c matkey.c pwm.c usart.c stepMotor.c
