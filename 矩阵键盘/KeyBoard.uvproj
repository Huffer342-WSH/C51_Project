# Keil uVision project KeyBoard.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: KeyBoard +hex
  c flags: Optimize=9
  c include: .\Core\inc
  group Source Group 1
    ./: STARTUP.A51
  group Core
    ./Core/src/: KeyBoard.c main.c Delay.c usart.c
