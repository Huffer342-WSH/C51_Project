# Keil uVision project 超声波测距.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: 超射波测距 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
  group Core
    ./Core/: delay.c eeprom.c usart.c main.c
  group Hardware
    ./Core/: hcsr04.c
