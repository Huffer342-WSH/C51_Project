# Keil uVision project PCF8591.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: PCF8591 +hex
  c flags: Optimize=9
  c include: .\Core
  group Source Group 1
    ./: STARTUP.A51
  group Core
    ./Core/: main.c I2C.c pcf8591.c
