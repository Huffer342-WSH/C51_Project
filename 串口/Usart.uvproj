# Keil uVision project Usart.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: Usart +hex
  c flags: Optimize=9
  c include: .\Core\inc
  group Source Group 1
    ./: STARTUP.A51
  group Core
    ./Core/src/: main.c usart.c
    C:/Users/hp/Desktop/: 111.txt
