# Keil uVision project practice.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: practice +hex
  c flags: Optimize=9
  group Source Group 1
    ./: STARTUP.A51
  group Core
    ./Core/: main.c delay.c i2c.c lcd12864_s.c pcf8591.c usart.c ds1302.c hcsr04.c pwm.c matkey.c speedometer.c NixieTube_74hc595.c eeprom.c
