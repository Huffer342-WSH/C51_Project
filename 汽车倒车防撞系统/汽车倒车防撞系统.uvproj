# Keil uVision project 汽车倒车防撞系统.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: 汽车倒车防撞系统 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
  group Core
    ./Core/: adc.c delay.c eeprom.c main.c pwm.c usart.c
  group Hareware
    ./Core/: hcsr04.c lcd12864_s.c speedometer.c matkey.c
